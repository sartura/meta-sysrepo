FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-keystored-remove-install-commads-from-cmake.patch"
